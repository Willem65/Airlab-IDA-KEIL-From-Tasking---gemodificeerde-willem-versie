# Keil uVision project Airlab-80c552.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C552 NXP
  cpu: IRAM(0-0xFF) CLOCK(30000000)
  output: Airlab-80c552 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: airlabbrm-willem.c REG552.H Delay.c Delay.h I2C.h I2C.c LCD.c LCD.h airlabbrm-willem.h ReadModules.c ReadModules.h RS232.c RS232.h ConsoleTimer.c ConsoleTimer.h Events.c Events.h
